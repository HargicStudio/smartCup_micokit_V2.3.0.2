<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3165</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-3288</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
          </package>
          <package>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
            <group>
              <check></check>
            </group>
          </package>
        </cstatsettings>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\User\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\User\syscom.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\User\user_debug.c</name>
      </file>
    </group>
    <group>
      <name>battery</name>
    </group>
    <group>
      <name>key</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\key\key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\key\key.h</name>
      </file>
    </group>
    <group>
      <name>led</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\led\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\led\led.h</name>
      </file>
    </group>
    <group>
      <name>mp3</name>
      <group>
        <name>fatfs</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\option\cc936.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\diskio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\ff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\ff.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\ffconf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\fatfs\src\integer.h</name>
        </file>
      </group>
      <group>
        <name>sd</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\sd\mmc_sd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\sd\mmc_sd.h</name>
        </file>
      </group>
      <group>
        <name>vs10xx</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\vs10xx\vs10xx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\vs10xx\vs10xx.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\mp3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\mp3\mp3.h</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>Factory</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Factory\If_MO.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Factory\OMFactory.c</name>
        </file>
      </group>
      <group>
        <name>fogCloud</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\fogCloud.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\fogCloud.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MICOAppDefine.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MICOAppEntrance.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MICOBonjour.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MICOConfigDelegate.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MicoFogCloud.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MicoFogCloud.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MicoFogCloudConfigServer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\fogCloud\MicoFogCloudDef.h</name>
        </file>
      </group>
      <group>
        <name>Monitor</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Monitor\DeviceMonitor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Monitor\HealthMonitor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Monitor\LightsMonitor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\Monitor\MusicMonitor.c</name>
        </file>
      </group>
      <group>
        <name>user</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\mico_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\Object_int.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\SendJson.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\user_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\user_downstream.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\user_main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Demos\SmartCup\net\user\user_upstream.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>smartCup</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\SmartCup\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\SmartCup\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\SmartCup\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>FogCloud</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\FogCloud\FogCloudService.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\FogCloud\FogCloudServiceDef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\FogCloud\FogCloudUtils.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>protocols</name>
      <group>
        <name>FogCloud</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\protocols\fog_cloud\FogCloud_cm4_debug.a</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\protocols\fog_cloud\FogCloud_cm4_release.a</name>
        </file>
      </group>
      <group>
        <name>Sntp</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\protocols\sntp\sntp.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>utilities</name>
      <group>
        <name>json_c</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\arraylist.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_object.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_tokener.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\json_util.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\linkhash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\json_c\printbuf.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\CheckSumUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\HTTPUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\RingBufferUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\SocketUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\StringUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TimeUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\TLVUtils.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\libraries\utilities\URLUtils.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>core</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mico_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm4f_8801.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\core\mxchipWNet_cm4f_sdio.a</name>
      </file>
    </group>
    <group>
      <name>system</name>
      <group>
        <name>command_console</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\command_console\mico_cli.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\command_console\mico_cli.h</name>
        </file>
      </group>
      <group>
        <name>config_server</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\config_server\config_server_menu.c</name>
        </file>
      </group>
      <group>
        <name>easylink</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\easylink\system_easylink_delegate.c</name>
        </file>
      </group>
      <group>
        <name>mdns</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\mdns\mico_mdns.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\mdns\mico_mdns.h</name>
        </file>
      </group>
      <group>
        <name>tftp_ota</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp_ota.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftp_ota.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\MICO\system\tftp_ota\tftpc.o</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_monitor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_notification.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_para_storage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\mico_system_power_daemon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_factory_test.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\system\system_misc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MicoDriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>STM32F4xx</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\EWARM\startup_stm32f411xe_IAR.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>STM32F4xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash_ramfunc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\system_stm32f4xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\paltform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_nano_second.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>Wi-Fi_Bus_Driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_bus_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\wlan_bus_driver\wlan_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\STM32F4xx\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
</project>


