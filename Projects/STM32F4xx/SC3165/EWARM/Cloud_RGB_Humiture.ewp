# IAR project Cloud_RGB_Humiture.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=26000000; MICOKIT_3165; USER_DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\MICO\system; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\protocols\sntp; ..\..\..\..\MICO\security; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\FogCloud; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\Board\SC3165; ..\..\..\..\Demos\SC3165\user; ..\..\..\..\Demos\SC3165\led; ..\..\..\..\Demos\SC3165\key; ..\..\..\..\Demos\SC3165\battery; ..\..\..\..\Demos\SC3165\net; ..\..\..\..\Demos\SC3165\net\fogCloud; ..\..\..\..\Demos\SC3165\net\user; ..\..\..\..\Demos\SC3165\net\Monitor; ..\..\..\..\Demos\SC3165\net\Factory
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Cloud_RGB_Humiture.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; HSE_VALUE=16000000; MICOKIT_3288; USER_DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\MICO\system; ..\..\..\..\libraries\utilities; ..\..\..\..\libraries\protocols\sntp; ..\..\..\..\MICO\security; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\include\FogCloud; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\Board\SmartCup; ..\..\..\..\Demos\SmartCup\user; ..\..\..\..\Demos\SmartCup\mp3; ..\..\..\..\Demos\SmartCup\mp3\sd; ..\..\..\..\Demos\SmartCup\mp3\fatfs\src; ..\..\..\..\Demos\SmartCup\mp3\vs10xx; ..\..\..\..\Demos\SmartCup\led; ..\..\..\..\Demos\SmartCup\key; ..\..\..\..\Demos\SmartCup\battery; ..\..\..\..\Demos\SmartCup\net; ..\..\..\..\Demos\SmartCup\net\fogCloud; ..\..\..\..\Demos\SmartCup\net\user; ..\..\..\..\Demos\SmartCup\net\Monitor; ..\..\..\..\Demos\SmartCup\net\Factory
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3288\micoLinkerForIAR.icf
  group Board/SC3165
    ../../../../Board/SC3165/: platform.c platform.h platform_config.h
  group Application/key
    ../../../../Demos/SC3165/key/: key.c
  group Application/led
    ../../../../Demos/SC3165/led/: led.c
  group Application/net/factory
    ../../../../Demos/SC3165/net/Factory/: If_MO.c OMFactory.c
  group Application/net/fogcloud
    ../../../../Demos/SC3165/net/fogCloud/: fogCloud.c fogCloud.h MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoFogCloud.c MicoFogCloud.h MicoFogCloudConfigServer.c MicoFogCloudDef.h
  group Application/net/monitor
    ../../../../Demos/SC3165/net/Monitor/: DeviceMonitor.c HealthMonitor.c LightsMonitor.c MusicMonitor.c
  group Application/User
    ../../../../Demos/SC3165/User/: main.c user_debug.c
  group include
    ../../../../include/: MICO.h
  group include/FogCloud
    ../../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group Library/protocols/FogCloud
    ../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a
  group Library/protocols/Sntp
    ../../../../libraries/protocols/sntp/: sntp.c
  group Library/utilities
    ../../../../libraries/utilities/: CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group Library/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group MICO/core
    ../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a
  group MICO/system
    ../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
  group MICO/system/command_console
    ../../../../MICO/system/command_console/: mico_cli.c mico_cli.h
  group MICO/system/config_server
    ../../../../MICO/system/config_server/: config_server.c config_server_menu.c
  group MICO/system/easylink
    ../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
  group MICO/system/mdns
    ../../../../MICO/system/mdns/: mico_mdns.c mico_mdns.h
  group MICO/system/tftp_ota
    ../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/MCU/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/MCU/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/MCU/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
